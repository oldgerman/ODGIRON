# Repository oldgerman/ODGIRON

File README.md:

# ODGIRON

## 关于

> 这是一个很久以前的项目，也是我刚学习stm32做的第一个项目，仅给老友们发车了10个套件，现将其所有软硬件资料开源
>
> Github仓库链接：https://github.com/oldgerman/ODGIRON

开源USB-C PD T12电烙铁，基于HAL库开发，STM32CubeIDE + STM32CubeMX

固件从 [ironOS](https://github.com/Ralim/IronOS) 修改而来，运行FreeRTOS，更换了主控，重新设计了主界面和多级菜单，更大的oled显示屏，分辨率128x32

双面板设计，电阻电容最小0603封装，焊接难度比0402小

前期准备几乎兼容所有QFN48、RAM ≥ 20KB、FLASH ≥ 128KB 的STM32芯片，但后期发现 F103 固件写不下了遂停止维护，主力适配 F401，当然如果你有能力，可自行移植到其他型号上

## 技术大纲

## 成品

## 硬件

### 配置

- 主控：STM32F103CBU6、STM32F401CCU6
- 屏幕：0.87inch OLED，SSD1316 分辨率128x32
- PD协议芯片：FUSB302B
- 加速度计：LIS3DH
- 功率计：INA226
- 电源管理：MP2456 + LDO 3.3V
- 温度测量：SGM8551 + MCP9700AT
- 功率MOS：AON7403（-30V/-29A）*2
- 外壳：尼龙3D打印

### PCB

### 原理图

### 外壳

## 软件

[固件版本更新日志](https://github.com/oldgerman/ODGIRON/blob/master/Notes/firmware_logs.md)

[固件升级方法](https://github.com/oldgerman/ODGIRON/blob/master/Notes/firmware_upgrade.md)

### 功能

- :heavy_check_mark:功率计

- :heavy_check_mark:自动休眠、运动唤醒

- :heavy_check_mark:温度功率曲线绘制

- :heavy_check_mark:USB固件升级

- :heavy_check_mark:多级菜单（可配置的参数太多，只列举几个）

  - 温度校准
  - 冷却休眠
  - 枚举PD挡位
  - ...

- :heavy_check_mark:断电保存设置

- 待开发

  - 多语言支持（目前仅支持中文）

  - ...

### BUG

ADC注入通道测量尖端的温度：STM32F401CCU6偶尔会向上抖动10度，同样的代码在STM32F103CBU6跑却很稳定，可能是ADC时钟频率、采样周期、转换周期不同导致，目前整不好了，但影响不大:)

## 致谢

> 感谢[@Miniware](http://www.miniware.com.cn/)开源的[TS100资料](http://www.minidso.com/forum.php?mod=viewthread&tid=892)
>
> 感谢[@Ralim](https://github.com/Ralim)开发的[ironOS](https://github.com/Ralim/IronOS)
>
> 感谢[@olikraus](https://github.com/olikraus)开发的[u8g2](https://github.com/olikraus/u8g2)
>
> 感谢[@Zanduino](https://github.com/Zanduino)开发的[INA](https://github.com/Zanduino/INA)

## EAGLE design Hardware/Datasheets/STUSB4500/SparkFunPowerDeliveryBoardEagleFiles/SparkFun_STUSB4500_USB-PD.brd

Parts:
C1, C2, C6: 1.0uF; 0603
C3: 0.1uF; 0603
D1: BLUE; LED-0603
D2: Yellow; LED-0603
D3: GREEN; LED-0603
D4: BAT60A; SOD-323
D5, D6, D7, D8: 24V; 0603
FD1, FD2, FD3, FD4: FIDUCIALUFIDUCIAL; FIDUCIAL-MICRO
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
H1, H2, H3, H4: STAND-OFF
J1: USB_C2-LAYER; USB-C-16P
J3: CONN_06NO_SILK_NO_POP; 1X06_NO_SILK
J4: QWIIC; JST04_1MM_RA
J5: CONN_023.5MM; SCREWTERMINAL-3.5MM-2
J6: CONN_021X02_NO_SILK; 1X02_NO_SILK
J7: CONN_07NO_SILK; 1X07_NO_SILK
JP1: JUMPER-SMT_3_2-NC_TRACE_NO-SILK; SMT-JUMPER_3_2-NC_TRACE_NO-SILK
JP2, JP3: JUMPER-SMT_2_NC_TRACE_NO-SILK; SMT-JUMPER_2_NC_TRACE_NO-SILK
LOGO1: OSHW-LOGOS; OSHW-LOGO-S
LOGO2: SFE_LOGO_NAME.1_INCH; SFE_LOGO_NAME_.1
LOGO3: QWIIC_LOGO_5MM; QWIIC_5MM
Q1: 9A/30V/15mΩ; 8-POWERVDFN-3X3
R1, R2, R5, R8: 100k; 0603
R3, R7, R11, R12, R13: 1k; 0603
R4: 22k; 0603
R6: 100; 0603
R9, R10: 2.2k; 0603
S1: MOMENTARY-SWITCH-SPST-SMD-4.6X2.8MM; TACTILE_SWITCH_SMD_4.6X2.8MM
U1: STUSB4500; QFN-24

Connections:
1.2V: C2.1, U1.P$21 (VREG_1V2)
2.7V: C1.1, D4.A, U1.P$23 (VREG_2V7)
!ALERT: J7.5, U1.P$19 (ALERT)
ADDR0: JP2.2, R1.1, U1.P$12 (ADDR0)
ADDR1: JP3.2, R2.1, U1.P$13 (ADDR1)
CC1: D6.2 (C), J1.A5 (CC1), U1.P$1 (CC1DB), U1.P$2 (CC1)
CC2: D7.2 (C), J1.B5 (CC2), U1.P$4 (CC2), U1.P$5 (CC2DB)
D+: J1.A6 (D+), J1.B6 (D+), J7.4
D-: J1.A7 (D-), J1.B7 (D-), J7.3
DISCH: R7.2, U1.P$9 (DISCH)
EN_SNK: R4.1, U1.P$16 (VBUS_EN_SNK)
GND: C1.2, C2.2, C6.2, D5.1 (A), D6.1 (A), D7.1 (A), D8.1 (A), J1.GND, J1.GND2 (GND), J3.4, J4.1, J5.2, J6.2, J7.2, JP2.1, JP3.1, R8.1, U1.P$10 (GND), U1.P$25 (GND)
GPIO: D1.C, J7.7, U1.P$15 (GPIO)
unnamed: D2.A, R11.1
unnamed: D3.A, R12.1
unnamed: JP1.3, R9.2
unnamed: JP1.1, R10.2
unnamed: Q1.4 (G), R4.2, R5.1, R6.1
unnamed: C3.2, R6.2
unnamed: D1.A, R13.1
POWER_PDO2: D3.C, J3.5, U1.P$20 (POWER_OK2)
POWER_PDO3: D2.C, J3.6, U1.P$14 (POWER_OK3)
RESET: J7.6, R8.2, S1.3 (2), S1.4 (2), U1.P$6 (RESET)
SCL: J3.1, J4.4, R9.1, U1.P$7 (SCL)
SDA: J3.2, J4.3, R10.1, U1.P$8 (SDA)
SHIELD: J1.SHLD1 (SHLD), J1.SHLD2 (SHLD), J1.SHLD3 (SHLD), J1.SHLD4 (SHLD), J1.SHLD5 (SHLD), J1.SHLD6 (SHLD), J1.SHLD7 (SHLD), J1.SHLD8 (SHLD)
VBUS_VS_DISCH: R3.1, U1.P$18 (VBUS_VS_DISCH)
VDD: D4.C, J3.3, J4.2, JP1.2, R1.2, R2.2, R11.2, R12.2, R13.2, S1.1, S1.2 (1), U1.P$22 (VSYS)
VIN: C6.1, D5.2 (C), J1.VBUS1 (VBUS), J1.VBUS2 (VBUS), J7.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), R3.2, R5.2, U1.P$24 (VDD)
VSNK: C3.1, D8.2 (C), J5.1, J6.1, Q1.5@1 (D), Q1.5@2 (D), Q1.5@3 (D), R7.1

Notes on the sheet:
ADDR0 and ADDR1 sets I2C address: ADDR0 | ADDR1 | Address 0 | 0 | 0x28* 1 | 0 | 0x29 0 | 1 | 0x2A 1 | 1 | 0x2B * Default Address 0: Jumper Closed 1: Jumper Open
Alex Wende
v10
STUSB4500
Connectors
I2C Pull-Up
LEDs
Reset Switch
I2C Address Jumpers
VIN: 4.1 - 22V
7.6A/30V/ 29mΩ
ESD Protection
VDD (optional): 3.0 - 5.5V
Cut both sides of JP1 to disable pull up resistors.

Board: 2 copper layers, 35.2 x 32.6 mm, 77 parts (27 on the bottom side), 30 nets.

Other parts of the board:
U$1: VDD2
U$2, U$11: GND6
U$3: SDA11
U$4: SCL12
U$5: #GPIO0
U$7: D#8
U$8: D#7
U$9: USB#C1
U$10: RESET10
U$12: VIN6
U$13: I2C2
U$14: PU3
U$15: ADDR00
U$16: ADDR11
U$17: RESET7
U$18: GPIO1
U$19: PDO24
U$20: PDO35
U$21, U$24: VSNK1
U$22, U$23: GND0
U$25: SFE_LOGO_FLAME_.1
U$26: #ALERT0
U$27: _POWER_DELIVERY2
U$29: #PDO20
U$30: #PDO31

## EAGLE design Hardware/PCB_Project/0.91_FUSB302/FUSB302_0.91.brd

Parts:
C1, C2, C4: 100nF; 0603
C3, C5, C15, C16, C17, C18: 1uF; 0603
C6, C7: 470pF; 0603
C19, C20, C21: 10uF; 0603
D2: 1N4148; SOD-323F
FD5, FD6, FD7, FD8: FIDUCIAL_MINI1X2; FIDUCIAL-1X2
J2, J4: CONN_11; 1X11
J3: USB_C_LONG-SYMBOL2-LAYER; USB-C-16P
J5: FEMALE 2x3; 2X3
LCD2: 0.91INCH_OLED_128X32_CH1115; 0.91INCH_128X32_OLED_CH1115
Q3, Q4: BSS138; SOT23-WIDE
R1, R2, R3, R12, R13, R14, R15, R16: 10K; 0603
R5: 0R; 0603
R11: 390K; 0603
U1: FUSB302; QFN14-2.5X2.5MM
U$5: 5.08MM_CONN; 1715250000
U$24: ME6211C33M5G-N; SOT23-5
VD1: USBLC6-4SC6; SOT23-6

Connections:
3.3V: C17.2, J5.4, LCD2.5 (VBAT), Q3.1 (G), Q4.1 (G), R12.2, R13.2, R16.2, U$24.5 (OUT)
5V: C1.1, J4.4, VD1.5
!INT: J4.10, R3.2, U1.5 (!INT)
CC1: C7.1, J3.A5 (CC1), U1.10 (CC1_01), U1.11 (CC1_02), VD1.6
CC2: C6.1, J3.B5 (CC2), U1.1 (CC2_01), U1.14 (CC2_02), VD1.1
D+: J3.A6 (D+), J3.B6 (D+), J4.6, VD1.3
D-: J3.A7 (D-), J3.B7 (D-), J4.5, VD1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C17.1, C18.1, C19.1, C20.1, C21.2, J2.6, J2.7, J2.8, J2.9, J2.10, J3.GND, J3.GND2 (GND), J4.1, J4.2, J4.3, J5.1, LCD2.7 (VSS), R5.1, R11.1, U1.8 (GND_01), U1.9 (GND_02), U1.THERMAL (GND_03), U$5.P$2, U$24.2 (GND), VD1.2
unnamed: J3.SHLD1 (SHLD), J3.SHLD2 (SHLD), J3.SHLD3 (SHLD), J3.SHLD4 (SHLD), J3.SHLD5 (SHLD), J3.SHLD6 (SHLD), J3.SHLD7 (SHLD), J3.SHLD8 (SHLD), R5.2
unnamed: C18.2, LCD2.8 (VDD)
unnamed: C15.2, LCD2.1 (C2+)
unnamed: C15.1, LCD2.2 (C2-)
unnamed: C16.2, LCD2.3 (C1+)
unnamed: C16.1, LCD2.4 (C1-)
unnamed: C20.2, LCD2.13 (VCOMH)
unnamed: LCD2.12 (IREF), R11.2
unnamed: C19.2, LCD2.14 (VCC)
RES_3.3V: D2.A, LCD2.9 (RES#), R16.1
RES_5.0V: D2.C, J5.3
SCL: J4.9, R2.2, U1.6 (SCL)
SCL_3.3V: LCD2.10 (SCL), Q4.2 (S), R13.1
SCL_5.0V: J5.5, Q4.3 (D), R15.1
SDA: J4.8, R1.2, U1.7 (SDA)
SDA_3.3V: LCD2.11 (SDA), Q3.2 (S), R12.1
SDA_5.0V: J5.6, Q3.3 (D), R14.1
VBREF: LCD2.6 (VBREF)
VBUS_C: J2.1, J2.2, J2.3, J2.4, J2.5, J3.VBUS1 (VBUS), J3.VBUS2 (VBUS), U1.2 (VBUS), U$5.P$1
VCONN: C4.1, C5.1, J2.11, U1.12 (VCONN_01), U1.13 (VCONN_02)
VDD: C2.1, C3.1, J4.11, U1.3 (VDD_01), U1.4 (VDD_02)
VIN: C21.1, J5.2, R14.2, R15.2, U$24.1 (IN), U$24.3 (CE)
V_PULLUP: J4.7, R1.1, R2.1, R3.1

Notes on the sheet:
FUSB302B的I2C地址：0x09
VCONN（只有在插头上才会有该信号），当线缆里有芯片的时候，用来给线缆里的芯片供电（3.3V或5V）。
VCONN是插头里Source到电源线的电子提供，并经过不连接到CC线的CC引脚，初衷是给eMarker芯片供电。
OldGerman
v.10

Board: 2 copper layers, 81.3 x 15.2 mm, 40 parts (5 on the bottom side), 30 nets.

## EAGLE design Hardware/Datasheets/MEMS/LIS3DH/Adafruit-LIS3DH-Breakout-PCB-master/Adafruit LIS3DH Original.brd

File Hardware/Datasheets/MEMS/LIS3DH/Adafruit-LIS3DH-Breakout-PCB-master/README.md:

## Adafruit LIS3DH Triple-Axis Accelerometer (+-2g/4g/8g/16g) PCB
<a href="http://www.adafruit.com/products/2809"><br/>
Click here to purchase one from the Adafruit shop</a>

The LIS3DH is a very popular low power triple-axis accelerometer. It's low-cost, but has just about every 'extra' you'd want in an accelerometer:

3.3V regulator + level shifting, so you can safely use with any Arduino or microcontroller without the need for an external level shifter!
We kept seeing this accelerometer in teardowns of commercial products and figured that if it's the most-commonly used accelerometer, its worth having a breakout board!

This sensor communicates over I2C or SPI (our library code supports both) so you can share it with a bunch of other sensors on the same I2C bus. There's an address selection pin so you can have two accelerometers share an I2C bus.

To get you going fast, we spun up a custom made PCB in the STEMMA QT form factor, making them easy to interface with. The STEMMA QT connectors on either side are compatible with the SparkFun Qwiic I2C connectors. This allows you to make solderless connections between your development board and the LIS331s or to chain them with a wide range of other sensors and accessories using a compatible cable. We’ve of course broken out all the pins to standard headers and added a voltage regulator and level shifting so allow you to use it with either 3.3V or 5V systems such as the Raspberry Pi + Feather series or Arduino Uno respectively.

PCB files for the Adafruit LIS3DH Breakout. The format is EagleCAD schematic and board layout
- https://www.adafruit.com/product/2809

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit](https://www.adafruit.com)!

All text above must be included in any redistribution

Designed by Limor Fried/Ladyada for Adafruit Industries.
Creative Commons Attribution/Share-Alike, all text above must be included in any redistribution. 
See license.txt for additional information.

Parts:
C1: 0.1uF; 0805_10MGAP
C2, C3: 10µF; 0805-NO
D2: 1N4148; SOD-323
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP1: HEADER-1X3ROUND; 1X03_ROUND
JP2: HEADER-1X870MIL; 1X08_ROUND_70
Q1, Q2: BSS138; SOT23-WIDE
R1, R2, R3, R4, R5, R8: 10K; 0805-NO
U1: LIS3DHTR; LGA16_3X3MM
U2: MIC5225-3.3; SOT23-5
U$10, U$13: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
3.3V: C1.1, C2.1, JP2.2, Q1.1 (G), Q2.1 (G), R2.2, R3.2, R8.2, U1.1 (VDDIO), U1.14 (VDD), U2.5 (OUT)
ADC1: JP1.1, U1.16 (ADC1)
ADC2: JP1.2, U1.15 (ADC2)
ADC3: JP1.3, U1.13 (ADC3)
CS: D2.C, JP2.7
GND: C1.2, C2.2, C3.2, JP2.3, R1.1, U1.5 (GND), U1.10 (RES(GND)), U1.12 (GND), U2.2 (GND)
INT1: JP2.8, U1.11 (INT1)
unnamed: D2.A, R8.1, U1.8 (CS)
SCL: JP2.4, Q2.3 (D), R5.1
SCL_3.3V: Q2.2 (S), R3.1, U1.4 (SCL)
SDA: JP2.5, Q1.3 (D), R4.1
SDA_3.3V: Q1.2 (S), R2.1, U1.6 (SDA)
SDO: JP2.6, R1.2, U1.7 (SDO)
VIN: C3.1, JP2.1, R4.2, R5.2, U2.1 (IN), U2.3 (EN)

Notes on the sheet:
I2C
SCL (Pin 4) = Serial Clock
SDA (Pin 6) = Serial Data
SD0 (Pin 7) = SA0/Address LSB
* CS needs to be set off board to select SPI or I2C
CS High = I2C, Low = SPI
Defaults to I2C as-is (R8)
SDO pulled low by default (R1) to set I2C address LSB to 0
Bus Selection
SPI
SDA (Pin 6) = Data In (MOSI)
SDO (Pin 7) = Data Out (MISO)
Set SJ1 to make I2C
address LSB 1

Board: 2 copper layers, 20.3 x 20.3 mm, 23 parts (1 on the bottom side), 14 nets.

Other parts of the board:
U$9: PCBFEAT-REV-040
U$21: ADAFRUIT_2.5MM
U$22: ADAFRUIT_5MM

## EAGLE design Hardware/Datasheets/MEMS/LIS3DH/Sparkfun - LIS3DH_Breakout-master/Hardware/SparkFun_LIS3DH-Breakout.brd

File Hardware/Datasheets/MEMS/LIS3DH/Sparkfun - LIS3DH_Breakout-master/README.md:

SparkFun Triple Axis Accelerometer Breakout - LIS3DH
=============================================

[*SparkFun Triple Axis Accelerometer Breakout - LIS3DH(SEN-13963)*](https://www.sparkfun.com/products/13963)

This breakout board makes it easy to use the tiny LIS3DH accelerometer in your project. 
The LIS3DH is a smart low-power, three-axis, capacitive micro-machined accelerometer with 12 bits of resolution.

This product replaced the MMA-8452Q.

Repository Contents
-------------------
* **/Hardware** - All Eagle design files (.brd, .sch)
* **/Libraries** - Libraries for use with the <PRODUCT NAME>
* **/Production** - Production panel files (.brd)

Documentation
--------------
* **[Library](https://github.com/sparkfun/SparkFun_LIS3DH_Arduino_Library)** - Arduino library.
* **[Hookup Guide](https://learn.sparkfun.com/tutorials/lis3dh-hookup-guide)** - Basic hookup guide.
* **[SparkFun Fritzing repo](https://github.com/sparkfun/Fritzing_Parts)** - Fritzing diagrams for SparkFun products.
* **[SparkFun 3D Model repo](https://github.com/sparkfun/3D_Models)** - 3D models of SparkFun products. 
* **[SparkFun Graphical Datasheets](https://github.com/sparkfun/Graphical_Datasheets)** -Graphical Datasheets for various SparkFun products.

Version History
---------------
* [V_0.1](https://github.com/sparkfun/LIS3DH_Breakout/tree/V_0.1) - Prototype
* [V_H1.0_L1.0.0](https://github.com/sparkfun/LIS3DH_Breakout/tree/V_H1.0_L1.0.0) - Hardware version 1.0, library version 1.0.0. 

License Information
-------------------

This product is _**open source**_! 

Please review the LICENSE.md file for license information. 

If you have any questions or concerns on licensing, please contact techsupport@sparkfun.com.

Distributed as-is; no warranty is given.

- Your friends at SparkFun.

Parts:
C1: 0.1uF; 0402
C2: 10uF; 0603
FRAME2: FRAME-LETTER; CREATIVE_COMMONS
J1, J2: CONN_06NO_SILK_FEMALE_PTH; 1X06_NO_SILK
JP2, JP6: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
JP3, JP4: STAND-OFF
LOGO1, LOGO2: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
R1, R2: 4.7k; 0603
R3, R4: 10k; 0603
SJ1: SOLDERJUMPERNO; SJ_2S-NO
SJ2: JUMPER-PAD-3-NC_BY_TRACE; PAD-JUMPER-3-3OF3_NC_BY_TRACE_YES_SILK_FULL_BOX
U1: LIS3DH; LGA-16-3X3
U$1: OSHW-LOGOS; OSHW-LOGO-S

Connections:
!CS: J1.6, R4.1, U1.8 (!CS!/MODE)
ADC1: J2.2, U1.16 (ADC1)
ADC2: J2.3, U1.15 (ADC2)
ADC3: J2.4, U1.13 (ADC3)
GND: C1.2, C2.2, J1.1, J2.1, SJ1.1, U1.5 (GND), U1.10 (RES), U1.12 (GND)
INT1: J2.5, U1.11 (INT1)
INT2: J2.6, U1.9 (INT2)
unnamed: R2.2, SJ2.1
unnamed: R1.2, SJ2.3
SA0: J1.5, R3.1, SJ1.2, U1.7 (SA0/SDO)
SCL: J1.4, R1.1, U1.4 (SCL/SPC)
SDA: J1.3, R2.1, U1.6 (SDA/SDI)
VCC: C1.1, C2.1, J1.2, R3.2, R4.2, SJ2.2, U1.1 (VDDIO), U1.14 (VDD)

Notes on the sheet:
Closed: 0x18 (SA0 = 0) Open: 0x19 (SA0 = 1)
Address selection jumper SJ1
v10
Marshall Taylor
LIS3DH Breakout
SJ2 pulls up the SCK and SDA lines for I2C operation
MODES: I2C: Leave the copper-connected jumper SJ2 as default, use SJ1 to set the I2C address between 0x18 and 0x19. SJ1 is the LSB of the address. SPI 4-WIRE: Jumpers SJ2 can be opened to remove 4.7k load on the SPI lines. SJ1 must be open for SPI operation.
Accelerometer Circuitry
User Ports
Apply regulated 1.8-3.3V to VCC

Board: 2 copper layers, 22.9 x 12.7 mm, 19 parts (4 on the bottom side), 13 nets.

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
SparkFun-Sensors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
