# Repository oldgerman/ODGIRON (continued)

## EAGLE design Hardware/PCB_Project/ODGIRON-v1.0-F4x1-0412/Stencil/拼版+接地/ODGIRON-v1.0-F103-0410.brd

Parts:
AMP1: SGM8551XN5G/TR; SOT23-5
BUZ1: BUZZERBUZZER_5020; BUZZER_5020
C1, C2, C3, C4, C5, C6, C10, C11, C12, C13, C14, C16, C29: 0.1uF/50V; C0603
C7, C23: 4.7uF/10V; C0603
C8, C9: 10pF/50V; C0603
C15, C21, C22, C24, C31, C39: 1uF/16V; C0603
C17, C27: 10nF/50V; C0603
C18, C19: 470pF/50V; C0603
C20, C25, C26, C37: 10uF/10V; C0603
C30: 10uF/25V; C0805
C32: 100pF; C0603
C33: 4.7uF/50V; C0805
C34: 100pF/50V; C0603
CP1: FUSE_CLIPS_01
D1, D7, D9: B5819WS; SOD-323
D2, D5: SMF24A; SOD-123
D3: MMSZ5242BS-7-F; SOD-323
D6, D8: ESD5B5.0ST1; SOD-523
DA1: INA226; MSOP10
FB1, FB2, FB3, FB4, FB5: 1K; F0603
J3: USB_C_LONG-SYMBOL2-LAYER; USB-C-16P
L1: 33uH CBC3225T330KR; SMD,3.2X2.5X2.5MM
LCD1: 0.87inch SSD1316; 0.87INCH_128X32_OLED_SSD1306
LOGO1: OSHW-LOGONO_SILK; DUMMY
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6, PAD7, PAD8, PAD9, PAD10, PAD11, PAD12: PADTP16SQ; TP16SQ
Q2, Q3: AON7403; DFN8P-0.65-3X3X0.8MM
Q4: 600mA/40V; SOT23-3
R1, R13: 32.4K; R0603
R2: 124K; R0603
R3, R10, R16, R18, R19, R22, R25, R35: 4.7K; R0603
R4: 1.5K; R0603
R5, R6, R27, R28: 22R; R0603
R7, R12, R23, R41, R45: 1K; R0603
R8, R20, R42: 100K; R0603
R9, R11, R14, R38: 10K; R0603
R17: 560K; R0603
R24: 10mR ±1% ±50ppm/°C; R1206
R36, R37: 10R; R0603
R43: 2.37K ±0.1% ±25ppm/℃; R0603
R44: 750K ±0.1% ±25ppm/℃; R0603
S1, S2, S3, S5: TAC_SWITCHSMD; TACTILE_SWITCH_SMD
T1: HAKKO_T12_K-TYPE_WITH_FUSE_CLIPS_X2
TP1: PGND; TESTPOINT_ROUND_2MM
TP5: SWO; PAD.03X.03
U1: FUSB302BMPX; QFN14-2.5X2.5MM
U3: STM32F103CBU6; QFN48_7X7MM_0.5MM
U4: MP2456GJ; SOT23-6
U5: MCP9700AT-E/TT; SOT23-3@1
U6: MCP1700T-3302E/TT; SOT23-3
U8: LIS3DH; LGA-16-3X3
VD1: USBLC6-2SC6; SOT23-6
ZO1: 8MHz; 3.2X2.5_KX-7

Connections:
3.9V: C30.1, C32.1, FB1.1, L1.2, R2.1
+3V3: C2.1, C4.1, C5.1, C12.2, C13.2, C14.2, C15.1, C20.2, C23.2, C24.2, C37.2, C39.2, DA1.6 (VS), FB2.2, FB3.2, LCD1.5 (VBAT), LCD1.8 (VDD), R3.1, R4.2, R13.2, R16.1, R18.2, R19.2, R22.2, R23.2, R25.1, R38.1, S3.3, S3.4, U1.3 (VDD_01), U1.4 (VDD_02), U3.1 (VBAT), U3.24 (VDD_1), U3.36 (VDD_2), U3.48 (VDD_3), U5.1 (VDD), U6.2 (VO), U8.1 (VDDIO), U8.14 (VDD)
ADC1: U8.16 (ADC1)
ADC2: U8.15 (ADC2)
ADC3: U8.13 (ADC3)
AMP+: AMP1.3 (+IN), R42.1
AMP-: AMP1.4 (-IN), C34.2, R43.1, R44.2
BS: C29.1, U4.1 (BS)
CC1: C18.1, D8.K (C), J3.A5 (CC1), U1.1 (CC2_01), U1.14 (CC2_02)
CC2: C19.1, D6.K (C), J3.B5 (CC2), U1.10 (CC1_01), U1.11 (CC1_02)
CS: U8.8 (!CS!/MODE)
D+: J3.A6 (D+), J3.B6 (D+), VD1.3
D-: J3.A7 (D-), J3.B7 (D-), VD1.1
DCDC_IN: C33.1, D1.C, R20.2, U4.5 (IN)
EN: R20.1, U4.4 (EN)
GND: AMP1.2 (V-), BUZ1.- (LEAD-), C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.1, C14.1, C15.2, C16.1, C18.2, C19.2, C20.1, C23.1, C24.1, C25.2, C26.2, C27.2, C30.2, C31.1, C33.2, C37.1, C39.1, D2.A, D5.A, D6.A, D7.A, D8.A, D9.A, DA1.1 (A1), DA1.2 (A0), DA1.7 (GND), FB4.1, FB4.2, J3.GND, J3.GND2 (GND), J3.SHLD1 (SHLD), J3.SHLD2 (SHLD), J3.SHLD3 (SHLD), J3.SHLD4 (SHLD), J3.SHLD5 (SHLD), J3.SHLD6 (SHLD), J3.SHLD7 (SHLD), J3.SHLD8 (SHLD), LCD1.7 (VSS), PAD5.TP, PAD6.TP, PAD7.TP, PAD8.TP, Q4.2 (E), R1.1, R8.2, R12.1, R17.1, R43.2, S1.1, S1.2, S2.1, S2.2, S5.1, S5.2, T1.1A1, T1.1B1, U1.8 (GND_01), U1.9 (GND_02), U1.THERMAL (GND_03), U3.8 (VSSA/VREF-), U3.20 (PB2/BOOT1), U3.23 (VSS_1), U3.35 (VSS_2), U3.47 (VSS_3), U3.P$1 (VSS_1), U4.2 (GND)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
LDO_IN: C31.2, FB1.2, U6.3 (VI)
unnamed: R4.1, R5.1, R27.1, VD1.4
unnamed: R7.2, S3.1, S3.2
unnamed: D3.C, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S)
unnamed: C21.1, LCD1.1 (C2+)
unnamed: D3.A, Q2.4 (G), Q3.4 (G), R10.2, R35.1
unnamed: C22.1, LCD1.3 (C1+)
unnamed: C11.2, FB2.1, U3.9 (VDDA)
unnamed: C3.1, R9.2, S1.3, S1.4
unnamed: C21.2, LCD1.2 (C2-)
unnamed: C6.1, R14.2, S2.3, S2.4
unnamed: C22.2, LCD1.4 (C1-)
unnamed: C25.1, LCD1.13 (VCOMH)
unnamed: LCD1.12 (IREF), R17.2
unnamed: C26.1, LCD1.14 (VCC)
unnamed: Q4.1 (B), R11.1
unnamed: C32.2, R1.2, R2.2, U4.3 (FB)
unnamed: C16.2, Q4.3 (C), R35.2
unnamed: C17.1, R11.2, R12.2
unnamed: AMP1.5 (V+), FB3.1
unnamed: R6.1, R28.1, VD1.6
unnamed: FB5.1, U1.2 (VBUS)
unnamed: C1.1, DA1.10 (IN+), R36.1
unnamed: C1.2, DA1.9 (IN-), R37.1
unnamed: R41.2, U5.2 (VOUT)
NRST: C10.1, R23.1, S5.3, S5.4, U3.7 (NRST)
OSC_IN: C8.2, U3.5 (PF0/OSC_IN), ZO1.3
OSC_OUT: C9.2, U3.6 (PF1/OSC_OUT\), ZO1.1
OUT: AMP1.1 (OUT), C34.1, R44.1, R45.2
PA0: U3.10 (PA0)
PA1: U3.11 (PA1)
PA2/ADC2: R41.1, U3.12 (PA2)
PA3/T2C4: C17.2, U3.13 (PA3)
PA4: U3.14 (PA4)
PA5: U3.15 (PA5)
PA6: U3.16 (PA6)
PA7/T1CH1N/T3C2: BUZ1.+ (LEAD+), U3.17 (PA7)
PA8/T1C1: U3.29 (PA8)
PA9/T1C2: U3.30 (PA9)
PA10/IT_ACCEL_1: U3.31 (PA10), U8.11 (INT1)
PA11/USB_DM: R6.2, U3.32 (PA11)
PA12/USB_DP: R5.2, U3.33 (PA12)
PA13/SWDIO: R27.2, U3.34 (PA13)
PA14/SWCLK: R28.2, U3.37 (PA14)
PA15: U3.38 (PA15)
PB0/ADC8: R45.1, U3.18 (PB0)
PB1/IT_FUSB302: R16.2, U1.5 (!INT), U3.19 (PB1)
PB3/IT_ACCEL_2: TP5.P$1, U3.39 (PB3), U8.9 (INT2)
PB4: U3.40 (PB4)
PB5: U3.41 (PB5)
PB6/SCL1: LCD1.10 (SCL), R19.1, U3.42 (PB6)
PB7/SDA1: LCD1.11 (SDA), R18.1, U3.43 (PB7)
PB8&BOOT0_S3: R7.1, R8.1, U3.44 (BOOT0), U3.45 (PB8)
PB9/S1: R9.1, U3.46 (PB9)
PB10/SCL2: DA1.5 (SCL), R3.2, U1.6 (SCL), U3.21 (PB10), U8.4 (SCL/SPC)
PB11/SDA2: DA1.4 (SDA), R25.2, U1.7 (SDA), U3.22 (PB11), U8.6 (SDA/SDI)
PB12: U3.25 (PB12)
PB13/IT_INA226: DA1.3 (ALERT), R38.2, U3.26 (PB13)
PB14/MISO2: U3.27 (PB14)
PB15/S2: R14.1, U3.28 (PB15)
PC13: U3.2 (PC13)
PC14/OSC32_IN: U3.3 (PC14/OSC32_IN)
PC15/OSC32_OUT: U3.4 (PC15/OSC32_OUT)
PGND: CP1.1A, CP1.1B, PAD9.TP, PAD10.TP, PAD11.TP, PAD12.TP, TP1.P$1
RES_3.3V: C7.1, LCD1.9 (RES#), R22.1
SAO/SDO/ADDR: U8.7 (SA0/SDO)
SW: C29.2, D7.C, L1.1, U4.6 (SW)
T12+: C27.1, D9.C, PAD1.TP, PAD2.TP, PAD3.TP, PAD4.TP, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.9 (D), R13.1, R42.2, T1.1A, T1.1B
VBREF: LCD1.6 (VBREF)
VBUS-C: D1.A, FB5.2, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), R10.1, R24.1, R37.2
VUSB_IN: D2.C (K), D5.C (K), DA1.8 (VBUS), J3.VBUS1 (VBUS), J3.VBUS2 (VBUS), R24.2, R36.2

Notes on the sheet:
I2C地址：0x09
VCONN从电源取电，当线缆里有eMarker芯片时，给它供电（3.3V或5V）
R1=R2/(Vout/0.812-1) Vout = 3.9V, R1:R2 = 1:3.8 R1 R2 32.4K 124K
exchange is ok
I2C2_PULLUP
I2C1_PULLUP
Do not need pull up
OldGerman
v1.0
I2C1
I2C2
Accel： INT2:支持敲击中断，活动中断 INT1:不支持活动中断，支持某轴Data中断
1K小于ADC在14MHz下 1.5Cycles采样周期的输入源阻抗
INT
https://github.com/oldgerman/ODGIRON-PD-T12 https://github.com/Ralim/IronOS https://oldgerman.github.io/
I2C地址：0x3C

Board: 2 copper layers, 89.8 x 17.6 mm, 121 parts (56 on the bottom side), 66 nets.

Other parts of the board:
U$3: CREATIVE_COMMONS

## EAGLE design Hardware/Datasheets/MEMS/LIS3DH/Adafruit-LIS3DH-Breakout-PCB-master/Adafruit LIS3DH.brd

Parts:
C1: 0.1uF; 0603-NO
C2, C3: 10uF; 0805-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: GREEN; CHIPLED_0603_NOOUTLINE
D2: 1N4148; SOD-323
FID3, FID4: FIDUCIAL_1MM
JP2, JP3: HEADER-1X670MIL; 1X06_ROUND_70
Q2: BSS138; SOT363
R1, R3: 10K; RESPACK_4X0603
SJ1: SOLDERJUMPER; SOLDERJUMPER_ARROW_NOPASTE
U1: LIS3DHTR; LGA16_3X3MM
U2: AP2112K-3.3; SOT23-5
U$1, U$17, U$19, U$21: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
3.3V: C1.1, C3.1, JP3.2, Q2.2 (G), Q2.5 (G), R1.1, R1.5 (2), R1.7 (2), R1.8 (2), R3.2 (1), R3.4 (1), SJ1.1, U1.1 (VDDIO), U1.14 (VDD), U2.5 (OUT)
ADC1: JP2.3, U1.16 (ADC1)
ADC2: JP2.4, U1.15 (ADC2)
ADC3: JP2.5, U1.13 (ADC3)
CS: D2.C, JP2.1
GND: C1.2, C2.2, C3.2, CONN3.1 (GND), CONN4.1 (GND), D1.C, JP3.3, R1.6 (2), U1.5 (GND), U1.10 (RES(GND)), U1.12 (GND), U2.2 (GND)
INT1: JP3.6, U1.11 (INT1)
INT2: JP2.6, U1.9 (INT2)
unnamed: D1.A, R1.4 (1)
unnamed: D2.A, R1.2 (1), U1.8 (CS)
SCL: CONN3.4 (SCL), CONN4.4 (SCL), JP3.4, Q2.6 (D), R3.8 (2)
SCL_3V: Q2.1 (S), R3.7 (2), U1.4 (SCL)
SDA: CONN3.3 (SDA), CONN4.3 (SDA), JP3.5, Q2.3 (D), R3.6 (2)
SDA_3V: Q2.4 (S), R3.5 (2), U1.6 (SDA)
SDO: JP2.2, R1.3 (1), SJ1.2, U1.7 (SDO)
VCC: C2.1, CONN3.2 (V+), CONN4.2 (V+), JP3.1, R3.1, R3.3 (1), U2.1 (IN), U2.3 (EN)

Notes on the sheet:
I2C Pullups & Shift
STEMMA/I2C Headers
ON LED
Power supply
I2C
SCL (Pin 4) = Serial Clock
SDA (Pin 6) = Serial Data
SD0 (Pin 7) = SA0/Address LSB
* CS needs to be set off board to select SPI or I2C
CS High = I2C, Low = SPI
Defaults to I2C as-is (R8)
SDO pulled low by default (R1) to set I2C address LSB to 0
Bus Selection
SPI
SDA (Pin 6) = Data In (MOSI)
SDO (Pin 7) = Data Out (MISO)
Set SJ1 to make I2C
address LSB 1

Board: 2 copper layers, 17.8 x 25.4 mm, 25 parts (4 on the bottom side), 16 nets.

Other parts of the board:
U$12: ADAFRUIT_2.5MM
U$25: PCBFEAT-REV-040
U$30, U$31: STEMMAQT

## EAGLE design Hardware/Datasheets/MEMS/MPU9250/15335_9DoF_IMU_EagleFiles/SparkFun_IMU_Breakout_ICM-20948.brd

Parts:
C1, C4: 1.0uF; 0603
C2, C3: 0.1uF; 0603
D1: RED; LED-0603
FD1, FD2, FD3, FD4: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME2: FRAME-LEDGER; CREATIVE_COMMONS
H1, H2, H3, H4: STAND-OFF
J1, J2: QWIIC_CONNECTORJS-1MM; JST04_1MM_RA
J3, J4: CONN_06NO_SILK_NO_POP; 1X06_NO_SILK
JP2: ADR; SMT-JUMPER_2_NO_SILK
JP3: AUX; SMT-JUMPER_3_2-NC_TRACE_SILK
JP4: I2C PU; SMT-JUMPER_3_2-NC_TRACE_SILK
JP5: LED; SMT-JUMPER_2_NC_TRACE_SILK
LOGO1: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO2: OSHW-LOGOMINI; OSHW-LOGO-MINI
Q2, Q4, Q6, Q8, Q10, Q12, Q14, Q16: 20V/0.2A/8MHz/1.2Ω/1Vth; SOT-416FL
R9: 220; 0603
R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 2.2k; 0402-TIGHT
TP1: 1.8V; PAD.03X.03
U2: 9DoF IMU; QFN24-3X3
U3: 1.8V/100mA; SC70

Connections:
1.8V: C1.1, C2.1, D1.A, Q2.1 (G), Q4.1 (G), Q6.1 (G), Q8.1 (G), Q10.1 (G), Q12.1 (G), Q14.1 (G), Q16.1 (G), R10.2, R12.2, R14.2, R16.2, R18.2, R20.2, R22.2, R24.2, TP1.P$1, U2.8 (VDDIO), U2.13 (VDD), U3.5 (OUT)
!CS: Q2.2 (S), R10.1, U2.22 (!CS)
!CS!_VIN: J3.6, Q2.3 (D), R11.1
AD0/SDO: Q4.2 (S), R12.1, U2.9 (AD0/SDO)
AD0/SDO_VIN: J3.5, JP2.2, Q4.3 (D), R13.1
AUX_CL: Q12.2 (S), R20.1, U2.7 (AUX_CL)
AUX_CL_VIN: J4.5, Q12.3 (D), R21.1
AUX_DA: Q10.2 (S), R18.1, U2.21 (AUX_DA)
AUX_DA_VIN: J4.4, Q10.3 (D), R19.1
FSYNC: Q14.2 (S), R22.1, U2.11 (FSYNC)
FSYNC_VIN: J4.3, Q14.3 (D), R23.1
GND: C1.2, C2.2, C3.2, C4.2, J1.1, J2.1, J3.1, J4.1, JP2.1, JP5.1, U2.18 (GND), U2.20 (GND), U3.2 (GND)
INT: Q16.2 (S), R24.1, U2.12 (INT)
INT_VIN: J4.2, Q16.3 (D), R25.1
unnamed: C3.1, U2.10 (REGOUT)
unnamed: JP4.3, R15.2
unnamed: JP4.1, R17.2
unnamed: JP3.1, R21.2
unnamed: JP3.3, R19.2
unnamed: D1.C, R9.2
unnamed: JP5.2, R9.1
SCL/SCLK: Q6.2 (S), R14.1, U2.23 (SCL/SCLK)
SCL/SCLK_VIN: J1.4, J2.4, J3.4, Q6.3 (D), R15.1
SDA/SDI: Q8.2 (S), R16.1, U2.24 (SDA/SDI)
SDA/SDI_VIN: J1.3, J2.3, J3.3, Q8.3 (D), R17.1
VIN: C4.1, J1.2, J2.2, J3.2, J4.6, JP3.2, JP4.2, R11.2, R13.2, R23.2, R25.2, U3.1 (IN), U3.3 (EN)

Notes on the sheet:
VIN 1.8V to 5.5V
IMU (ICM-20948)
I2C Level Shifting + Pullup Disconnects
Connections
Voltage Regulator
SPI / Interrupt Level Shifting
ADR -> I2C Address ------------------- open -> 0x69 closed -> 0x68 *Closing AD0 precludes SPI
Optionally disconnect the I2C pullup resistors on the primary and auxillary busses in case of too strong pullup from other sources
Cut to disable PWR LED
Address Option

Board: 2 copper layers, 25.4 x 25.4 mm, 104 parts (36 on the bottom side), 26 nets.

Other parts of the board:
U$1, U$2, U$22, U$24: GND4
U$3: PWR0
U$4, U$21: INT3
U$5, U$20: FSNC2
U$6, U$19: ACL1
U$7, U$18: ADA0
U$8: MISO13
U$9: MOSI14
U$10: SCLK15
U$11: #CS16
U$12: 1V8#5V57
U$13, U$30, U$44: VIN5
U$14: NC17
U$15: CL4
U$16: DA2
U$17: AD012
U$23: ADR2
U$25: I2C_PU21
U$26: SPI19
U$27: AUX_PU24
U$28: SFE_LOGO_FLAME_.1
U$29: LED23
U$31: ICM#2094820
U$34, U$40, U$50, U$57: X0
U$35, U$41, U$51, U$58: Y1
U$36, U$42, U$52, U$59: Z2
U$37, U$60: G5
U$38, U$61: A4
U$39, U$49: M3
U$43: QWIIC_9DOF_IMU_0
U$45: I#C1

## EAGLE design Hardware/Datasheets/MEMS/MPU6050/Adafruit-MPU6050-PCB-master/Adafruit MPU6050.brd

File Hardware/Datasheets/MEMS/MPU6050/Adafruit-MPU6050-PCB-master/README.md:

## Adafruit MPU6050 6-DoF Accelerometer and Gyro PCB

<a href="http://www.adafruit.com/products/3886"><br/>
Click here to purchase one from the Adafruit shop</a>

PCB files for the Adafruit MPU6050 6-DoF Accelerometer and Gyro. 

Format is EagleCAD schematic and board layout
* https://www.adafruit.com/product/3886

### Description

The MPU-6050 is a popular six DoF accelerometer and gyroscope (gyro) that has all the info you need on how things are shakin' and spinnin' . With six axes of sensing and 16-bit measurements, you'll have everything you need to give your robot friend an inner ear.

This combination of gyroscopes and accelerometers is commonly referred to as an **I**nertial **M**easurement **U**nit or IMU. Not so long ago IMUs were the [size of a breadbox](http://mentalfloss.com/article/55835/how-big-breadbox) and cost upwards of **$50,000!** While you're not going to be using it to guide your mars rocket, the MPU-6050 is several orders of magnitude smaller and a bargain at a price three orders of magnitude less!  Now you can add telemetry to your [water rocket](https://en.wikipedia.org/wiki/Water_rocket) (with some waterproofing).

As with all Adafruit breakouts, we've done the work to make this handy temperature helper super easy to use. We've put it on a breakout board with the required support circuitry and connectors to make it easy to work with, and is now a trend we've added [SparkFun Qwiic](https://www.sparkfun.com/qwiic) compatible [STEMMA QT](https://learn.adafruit.com/introducing-adafruit-stemma-qt) JST SH connectors that allow you to get going without needing to solder. Just use a [STEMMA QT adapter cable](https://www.adafruit.com/product/4209), plug it into your favorite micro or Blinka supported SBC and you're ready to rock!

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit](https://www.adafruit.com)!

Designed by Bryan Siepert for Adafruit Industries.

Creative Commons Attribution/Share-Alike, all text above must be included in any redistribution. 
See license.txt for additional details.

Parts:
C1: 2.2nF; 0603-NO
C2, C7: 0.1uF; 0603-NO
C5, C6: 10uF; 0805-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: GREEN; CHIPLED_0603_NOOUTLINE
FID3, FID4: FIDUCIAL_1MM
JP2: HEADER-1X6ROUND; 1X06_ROUND
JP3: HEADER-1X670MIL; 1X06_ROUND_70
Q2: BSS138; SOT363
R2, R4: 10K; 0603-NO
R3: 10K; RESPACK_4X0603
SJ1: CLKIN; SOLDERJUMPER_CLOSEDWIRE
SJ2: FSYNC; SOLDERJUMPER_CLOSEDWIRE
SJ3: SOLDERJUMPER; SOLDERJUMPER_ARROW_NOPASTE
U1: MPU-6050; QFN24_4MM_SMSC
U3: AP2112K-3.3; SOT23-5
U$39, U$40, U$42, U$43: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
3.3V: C6.1, C7.1, JP3.2, Q2.2 (G), Q2.5 (G), R3.2 (1), R3.4 (1), R4.1, SJ3.1, U1.8 (VLOGIC), U1.13 (VDD), U3.5 (OUT)
AD0: JP2.1, R2.1, SJ3.2, U1.9 (AD0)
CLKIN: JP2.5, SJ1.2, U1.1 (CLKIN)
CPOUT: C1.1, U1.20 (CPOUT)
FSYNC_IN: JP2.2, SJ2.2, U1.11 (FSYNC)
GND: C1.2, C2.2, C5.2, C6.2, C7.2, CONN3.1 (GND), CONN4.1 (GND), D1.C, JP2.6, JP3.3, R2.2, SJ1.1, SJ2.1, U1.18 (GND), U1.THERM (THERMAL), U3.2 (GND)
INT: JP3.6, U1.12 (INT)
unnamed: D1.A, R4.2
REGOUT: C2.1, U1.10 (REGOUT)
SCL: CONN3.4 (SCL), CONN4.4 (SCL), JP3.4, Q2.6 (D), R3.8 (2)
SCL_3V: Q2.1 (S), R3.7 (2), U1.23 (SCL)
SCL_EXT: JP2.3, U1.7 (AUX_CL)
SDA: CONN3.3 (SDA), CONN4.3 (SDA), JP3.5, Q2.3 (D), R3.6 (2)
SDA_3V: Q2.4 (S), R3.5 (2), U1.24 (SDA)
SDA_EXT: JP2.4, U1.6 (AUX_DA)
VCC: C5.1, CONN3.2 (V+), CONN4.2 (V+), JP3.1, R3.1, R3.3 (1), U3.1 (IN), U3.3 (EN)

Notes on the sheet:
I2C Pullups & Shift
STEMMA/I2C Headers
ON LED
Power supply

Board: 2 copper layers, 25.4 x 17.8 mm, 28 parts (6 on the bottom side), 16 nets.

Other parts of the board:
U$46: PCBFEAT-REV-040
U$47, U$48: STEMMAQT

## Code that names these connections

File Software/workspace_ODGIRON/PROJECT_STM32F103/PROJECT_STM32F103.ioc (part):

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Mcu.Name=STM32F103CBUx
Mcu.Package=UFQFPN48
Mcu.UserName=STM32F103CBUx
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=TREF_TEMP
PA2.Signal=ADCx_IN2
PA3.GPIOParameters=GPIO_Speed,GPIO_Label
PA3.GPIO_Label=PWM_OUT
PA3.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA3.Signal=S_TIM2_CH4
PA4.Signal=ADCx_IN4
PA7.GPIOParameters=GPIO_ModeDefaultPP,GPIO_Speed,GPIO_Label
PA7.GPIO_Label=BUZZER_OUT
PA7.GPIO_ModeDefaultPP=GPIO_MODE_AF_PP
PA7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA7.Signal=S_TIM3_CH2
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=TIP_TEMP
PB0.Signal=ADCx_IN8
PB1.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PB1.GPIO_Label=IT_FUSB302B
PB1.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB1.GPIO_PuPd=GPIO_PULLUP
PB1.Signal=GPXTI1
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=SCL2
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=SDA2
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB15.GPIOParameters=GPIO_PuPd,GPIO_Label
PB15.GPIO_Label=KEY_OK
PB15.GPIO_PuPd=GPIO_PULLUP
PB15.Signal=GPIO_Input
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=SCL1
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=SDA1
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.GPIOParameters=GPIO_PuPd,GPIO_Label
PB8.GPIO_Label=KEY_B
PB8.GPIO_PuPd=GPIO_NOPULL
PB8.Signal=GPIO_Input
PB9.GPIOParameters=GPIO_PuPd,GPIO_Label
PB9.GPIO_Label=KEY_A
PB9.GPIO_PuPd=GPIO_PULLUP
PB9.Signal=GPIO_Input
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2021-08-09 2 commit
2021-08-09 3 commit
2021-08-09 4 commit
2021-08-10 5 commit, 添加菜单滚动栏动画
2021-08-10 6 commit，修复重启进入DFU功能的USB无法识别
2021-08-11 7 commit，增加菜单栏迭代跟随运动，主页调温的衔接动效
2022-04-04 移除F103CBU6的固件
2022-04-04 更新固件
2022-04-24 添加校准目标温度可调功能
2022-04-27 添加温度失控保护
2022-12-01 添加ODGIRON_20210624之前的相关文件
2023-07-02 2023-07-02_11:59
2023-07-02 2023-07-02_11:01
